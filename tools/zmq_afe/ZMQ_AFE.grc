options:
  parameters:
    generate_options: qt_gui
    id: ZMQ_AFE
    output_language: python
    title: ZMQ AFE Playground
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    name: RF input spectra
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: float
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [zeromq_req_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_req_source_0, '0', zeromq_rep_sink_0, '0']

metadata:
  file_format: 1
